# Keil uVision project SC0X.uvprojx, settings and files
target SC0X (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SC0X +hex
  AfterMake: fromelf --bin !L --output ..\..\bin\obj\SC0X-S-ARM.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\include;..\..\components\drivers\include;..\..\components\finsh;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\bsp\stm32f40x;..\..\bsp\stm32f40x\Libraries\CMSIS\Include;..\..\bsp\stm32f40x\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\bsp\stm32f40x\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\bsp\stm32f40x\applications;..\..\bsp\stm32f40x\drivers;..\..\bsp\stm32f40x\TOOLS;..\..\bsp\stm32f40x\flash;..\..\bsp\stm32f40x\mvb;..\..\bsp\stm32f40x\cpptools;..\..\bsp\stm32f40x\userApp;..\..\components\net\freemodbus-v1.6.0\port;..\..\components\net\freemodbus-v1.6.0\modbus\include;..\..\components\net\freemodbus-v1.6.0\modbus\rtu
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../../bsp/stm32f40x/applications/: application.c startup.c serial_comm_util.c iap_service.c
  group userApp
    ../../bsp/stm32f40x/userApp/: thread_x_run.c logicApp.c Sc.cpp ScManager.cpp appMonitor.cpp appModule.cpp ScCheck.cpp Bsp_Board_Init.c canApp.cpp canTask.c ScData.cpp
  group Drivers
    ../../bsp/stm32f40x/drivers/: board.c can.c stm32f4xx_it.c Bsp_systimer.c hardware_crc32.c update_application.c own_flash.c usart.c io.c fsmc.c ad.c cpuusage.c
  group STM32_StdPeriph
    ../../bsp/stm32f40x/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c
    ../../bsp/stm32f40x/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
    ../../bsp/stm32f40x/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group CORTEX-M4
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/can/: can.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
  group cpptools
    ../../bsp/stm32f40x/cpptools/: Contactor.cpp DCTransducer.cpp Failure.cpp FailureCheck.cpp IOTransducer.cpp Product.cpp Relay.cpp RelayModule.cpp NTC.cpp PID.cpp PT100.cpp ScFailure.cpp
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group flash
    ../../bsp/stm32f40x/drivers/: spi_flash.c
    ../../bsp/stm32f40x/flash/: stm32f20x_40x_spi.c flash_storage_at45dbxx.c spi_flash_at45dbxx.c
  group tools
    ../../bsp/stm32f40x/TOOLS/: static_mem.c support.cpp serial_protocol.c pcmaster.c crc16.c
  group FreeModbus
    ../../components/net/freemodbus-v1.6.0/port/: Bsp_mb_task.c user_mb_app.c port.c
    ../../components/net/freemodbus-v1.6.0/modbus/functions/: mbfuncother.c
    ../../components/net/freemodbus-v1.6.0/modbus/rtu/: mbcrc.c
  group FreeModbusSlave
    ../../components/net/freemodbus-v1.6.0/modbus/: mb.c
    ../../components/net/freemodbus-v1.6.0/modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbutils.c
    ../../components/net/freemodbus-v1.6.0/modbus/rtu/: mbrtu.c
    ../../components/net/freemodbus-v1.6.0/port/: portevent.c portserial.c porttimer.c
  group FreeModbusMaster
    ../../components/net/freemodbus-v1.6.0/modbus/: mb_m.c
    ../../components/net/freemodbus-v1.6.0/modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
    ../../components/net/freemodbus-v1.6.0/modbus/rtu/: mbrtu_m.c
    ../../components/net/freemodbus-v1.6.0/port/: portevent_m.c portserial_m.c porttimer_m.c
